# IAR project UDP_test_2.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2368 NXP LPC2368
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: UDP_test_2.hex
  ILINK.IlinkOutputFile: udp_test_2.out
  ILINK.IlinkIcfFile: LPC2378_tn_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group System files
    ./: startup_hardware_init.s79 tnkernel_startup_iar.s
  group Test files
    ../UDP_Test_2/: tdtp_cli.c tdtp_port.c tdtp_utils.c
    ../udp_test_2/: tn_sprintf.c tn_user.c udp_test_2.c utils.c
  group tn_net
    ../tn_net/: in4_cksum.c tn_arp.c tn_dhcp.c tn_icmp.c tn_in_pcb.c tn_ip_input.c tn_ip_output.c tn_mbuf.c tn_net_mem.c tn_net_utils.c tn_sockets.c tn_sockets_udp.c tn_tcp_input.c tn_tcp_output.c tn_tcp_sockets.c tn_tcp_sockets2.c tn_tcp_subr.c tn_tcp_timer.c tn_udp.c
  group tn_net/cpu_lpc23xx
    ../tn_net/cpu_lpc23xx/: lpc23xx_int.c lpc23xx_mac.c lpc23xx_mac_drv.c lpc23xx_net.c lpc23xx_phy_KS8721.c
  group TNKernel
    ../TNKernel/: tn.c tn_dqueue.c tn_event.c tn_mem.c tn_mutex.c tn_port.c tn_port_asm.s79 tn_sem.c tn_tasks.c tn_utils.c
